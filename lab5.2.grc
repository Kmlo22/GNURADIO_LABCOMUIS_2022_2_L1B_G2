options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: MultiplexPAM
    output_language: python
    title: MultiplexPAM
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud Mensaje '
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho Pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: D1
  id: variable_qtgui_range
  parameters:
    label: Retardo 1
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    label: retardo 2
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    label: Retardo 3
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: D4
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: 'Frecuencia Mesaje '
    start: '0'
    step: '10'
    stop: '10000'
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Pulsos
    start: '0'
    step: '1'
    stop: '10000'
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: Modulacion_0
  id: Modulacion
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Modulacion_1
  id: Modulacion
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Modulacion_2
  id: Modulacion
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Modulacion_3
  id: Modulacion
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Modulacion_4
  id: Modulacion
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_3
  id: blocks_delay
  parameters:
    delay: 100-D4
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 50e6
    gain0: '30'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Modulacion_0, '0', blocks_add_xx_0, '0']
- [Modulacion_0, '0', qtgui_time_sink_x_1, '0']
- [Modulacion_1, '0', blocks_delay_2, '0']
- [Modulacion_2, '0', blocks_delay_0, '0']
- [Modulacion_3, '0', blocks_delay_1, '0']
- [Modulacion_4, '0', blocks_float_to_complex_0, '0']
- [Modulacion_4, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', Modulacion_0, '0']
- [analog_sig_source_x_1, '0', Modulacion_3, '0']
- [analog_sig_source_x_2, '0', Modulacion_2, '0']
- [analog_sig_source_x_3, '0', Modulacion_1, '0']
- [blocks_add_xx_0, '0', blocks_delay_3, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '4']
- [blocks_delay_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0, '0', qtgui_time_sink_x_1, '2']
- [blocks_delay_1, '0', blocks_add_xx_0, '3']
- [blocks_delay_1, '0', qtgui_time_sink_x_1, '3']
- [blocks_delay_2, '0', blocks_add_xx_0, '1']
- [blocks_delay_2, '0', qtgui_time_sink_x_1, '1']
- [blocks_delay_3, '0', Modulacion_4, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
